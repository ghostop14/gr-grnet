options:
  parameters:
    generate_options: qt_gui
    id: test_udp_source6
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1691e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: grnet_udp_source_0
  id: grnet_udp_source
  parameters:
    header: '0'
    ipv6: 'True'
    notifyMissed: 'False'
    payloadsize: '1472'
    port: '2001'
    srcZeros: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    fc: center_freq
    fftsize: '2048'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '-30'
    ymin: '-60'
  states: {}

connections:
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_throttle_0, '0', blocks_probe_rate_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [grnet_udp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
