options:
  parameters:
    generate_options: qt_gui
    id: test_sc16
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 95.7e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/sdr/gnuradio/gnuradio_recordings/rtl_sdr_100M_2.048MSPS.converted.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: grnet_ComplexToSC16_0
  id: grnet_ComplexToSC16
  parameters: {}
  states: {}
- name: grnet_SC16ToComplex_0
  id: grnet_SC16ToComplex
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Raw
    label2: Converted
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', grnet_ComplexToSC16_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0_0, '0']
- [grnet_ComplexToSC16_0, '0', grnet_SC16ToComplex_0, '0']
- [grnet_SC16ToComplex_0, '0', qtgui_freq_sink_x_0_0, '1']

metadata:
  file_format: 1
