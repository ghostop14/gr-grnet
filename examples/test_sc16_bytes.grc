<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_sc16_bytes</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>95.7e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>value</key><value>12</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>6e6</value></param>
</block>
<block>
<key>grnet_BytesToSC16</key>
<param><key>id</key><value>grnet_BytesToSC16_0</value></param>
</block>
<block>
<key>grnet_Int16BytesToComplex</key>
<param><key>id</key><value>grnet_Int16BytesToComplex_0</value></param>
</block>
<block>
<key>grnet_Int16BytesToComplex</key>
<param><key>id</key><value>grnet_Int16BytesToComplex_0_0</value></param>
</block>
<block>
<key>grnet_SC16ToBytes</key>
<param><key>id</key><value>grnet_SC16ToBytes_0</value></param>
</block>
<block>
<key>grnet_SC16ToBytes</key>
<param><key>id</key><value>grnet_SC16ToBytes_0_0</value></param>
</block>
<block>
<key>grnet_SC16ToIShort</key>
<param><key>id</key><value>grnet_SC16ToIShort_0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymin</key><value>-80</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>frequency</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>int_min</key><value>-80</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>frequency</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>sc16</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>grnet_BytesToSC16_0</source_block_id><sink_block_id>grnet_SC16ToBytes_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_Int16BytesToComplex_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_Int16BytesToComplex_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_Int16BytesToComplex_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>grnet_SC16ToBytes_0</source_block_id><sink_block_id>grnet_BytesToSC16_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_SC16ToBytes_0</source_block_id><sink_block_id>grnet_Int16BytesToComplex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_SC16ToBytes_0_0</source_block_id><sink_block_id>grnet_Int16BytesToComplex_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>grnet_SC16ToIShort_0</source_block_id><sink_block_id>grnet_SC16ToBytes_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>grnet_SC16ToIShort_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
