options:
  parameters:
    generate_options: qt_gui
    id: test_sc16_bytes
    output_language: python
  states: {}

blocks:
- name: frequency
  id: variable
  parameters:
    value: 95.7e6
  states: {}
- name: gain
  id: variable
  parameters:
    value: '12'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 6e6
  states: {}
- name: grnet_BytesToSC16_0
  id: grnet_BytesToSC16
  parameters: {}
  states: {}
- name: grnet_Int16BytesToComplex_0
  id: grnet_Int16BytesToComplex
  parameters: {}
  states: {}
- name: grnet_SC16ToBytes_0
  id: grnet_SC16ToBytes
  parameters: {}
  states: {}
- name: grnet_SC16ToComplex_0
  id: grnet_SC16ToComplex
  parameters: {}
  states: {}
- name: grnet_SC16ToIShort_0
  id: grnet_SC16ToIShort
  parameters: {}
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymin: '-80'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: frequency
    fftsize: '1024'
    int_min: '-80'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: frequency
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: sc16
  states: {}

connections:
- [grnet_BytesToSC16_0, '0', grnet_SC16ToComplex_0, '0']
- [grnet_Int16BytesToComplex_0, '0', qtgui_freq_sink_x_0, '0']
- [grnet_Int16BytesToComplex_0, '0', qtgui_waterfall_sink_x_0, '0']
- [grnet_SC16ToBytes_0, '0', grnet_BytesToSC16_0, '0']
- [grnet_SC16ToBytes_0, '0', grnet_Int16BytesToComplex_0, '0']
- [grnet_SC16ToComplex_0, '0', qtgui_freq_sink_x_0, '1']
- [grnet_SC16ToIShort_0, '0', grnet_SC16ToBytes_0, '0']
- [uhd_usrp_source_0, '0', grnet_SC16ToIShort_0, '0']

metadata:
  file_format: 1
