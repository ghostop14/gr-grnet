options:
  parameters:
    generate_options: qt_gui
    id: test_udp_source
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: grnet_udp_source_0
  id: grnet_udp_source
  parameters:
    header: '1'
    ipv6: 'False'
    notifyMissed: 'True'
    payloadsize: '1472'
    port: '2001'
    srcZeros: 'False'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [grnet_udp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
