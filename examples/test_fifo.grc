options:
  parameters:
    generate_options: qt_gui
    id: test_fifo
    output_language: python
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 600e3
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /opt/sdr/gnuradio/gnuradio_recordings/NOAA_weather_radio_162.425MHz_NBFM_600KSPS_NoFilter.iq
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: grnet_FifoBuffer_0
  id: grnet_FifoBuffer
  parameters:
    minQueueLength: '24000'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label2: ''
    nconnections: '2'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', grnet_FifoBuffer_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [grnet_FifoBuffer_0, '0', qtgui_freq_sink_x_0, '1']

metadata:
  file_format: 1
